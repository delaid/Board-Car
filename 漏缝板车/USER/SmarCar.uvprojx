# Keil uVision project SmarCar.uvprojx, settings and files
target SmarCar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmarCar
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\HARDWARE\BALANCE;..\HARDWARE\APDS9960;..\HARDWARE\BLU_APP;..\HARDWARE\UITRA;..\HARDWARE\KEY;..\HARDWARE\POWER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/BLU_APP/: usart3.c usart1.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group CAR_CONTROL
    ../HARDWARE/BALANCE/: motor.c smartcar_control.c pid.c encoder.c Smar_time_task.c filter.c inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c MPU6050_IIC.c
  group PROTOCOL_APP
    ../HARDWARE/BLU_APP/: protocol.c
    ../HARDWARE/BALANCE/: pstwo.c
